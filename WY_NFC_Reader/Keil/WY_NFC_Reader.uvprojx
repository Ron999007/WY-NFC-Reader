# Keil uVision project WY_NFC_Reader.uvprojx, settings and files
target WY_NFC_Reader (6240000::V6.24::ARMCLANG)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x9FFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: WY_NFC_Reader
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_DEBUG_PRINT
  c include: ..\..\M480_BSP_CMSIS\Library\CMSIS\Include;..\..\M480_BSP_CMSIS\Library\Device\Nuvoton\M480\Include;..\..\M480_BSP_CMSIS\Library\StdDriver\inc;..\..\M480_BSP_CMSIS\ThirdParty\FatFs\source;..\inc;..\lib\MID\inc;..\lib\SYS\inc;..\lib\DRV\inc;..\lib\IO\inc;..\lib\PERIPH\inc;..\lib\CLI\inc;..\lib\UTILS\inc
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../M480_BSP_CMSIS/Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../M480_BSP_CMSIS/Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Library
    ../../M480_BSP_CMSIS/Library/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c spi.c spim.c epwm.c timer.c hsusbd.c i2c.c sdh.c can.c
  group lib-mid
    ../lib/MID/src/: mifare.c iso14443_4.c iso14443a.c iso14443b.c mid_shell.c mid_ymodem.c mid_mqtt.c
    ../../M480_BSP_CMSIS/ThirdParty/FatFs/source/: ff.c ffunicode.c
  group lib-sys
    ../lib/SYS/src/: Systick_For_Timeout.c Delay.c sys_console.c
  group lib-drv
    ../lib/DRV/src/: drv_bc45b4522.c drv_button.c drv_rgb.c drv_led.c drv_snor_flash.c drv_esp8266.c drv_oled_ssd1306.c drv_sd_card.c drv_buzzer.c drv_dht11.c drv_eeprom.c drv_rs232.c drv_rs485.c
  group lib-io
    ../lib/IO/inc/: uart_io.h i2c_io.h can_io.h
    ../lib/IO/src/: diskio.c
  group lib-periph
    ../lib/PERIPH/src/: periph_spi.c periph_uart.c periph_pwm.c periph_usb_desc.c periph_i2c.c periph_can.c
  group lib-utils
    ../lib/UTILS/src/: utils_ringbuffer.c
    ../lib/UTILS/inc/: utils_ringbuffer.h
  group User
    ../src/: MyApplication.c task_led.c task_rgb_led.c task_button.c task_console.c task_usb_vcom.c task_snor_flash.c task_ymodem.c task_wifi.c task_nfc_reader.c task_oled.c task_sdcard.c task_buzzer.c task_dht11.c task_eeprom.c task_rs232.c task_rs485.c task_can.c rfid.c bc45_cli.c image.c
    ../inc/: MyApplication.h task_led.h task_rgb_led.h task_button.h task_console.h task_usb_vcom.h task_snor_flash.h task_ymodem.h task_wifi.h task_nfc_reader.h task_oled.h task_sdcard.h task_buzzer.h task_dht11.h task_eeprom.h task_rs232.h task_rs485.h task_can.h main.h rfid.h bc45_cli.h image.h macro_utils.h
    ../: main.c
